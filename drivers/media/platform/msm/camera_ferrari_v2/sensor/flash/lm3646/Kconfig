## drivers/media/platform/msm/camera_ferrari_v2/sensor/flash/lm3646/Kconfig
```kconfig
config MSMB_CAMERA_SENSOR_FLASH_LM3646
	bool "LM3646 Flash sensor support"
	depends on MSMB_CAMERA
```
